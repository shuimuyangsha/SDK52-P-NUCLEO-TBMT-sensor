<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SDK52-P-NUCLEO-TBMT-sensor.ewp</path>
  </project>
  <batchBuild />
</workspace>
