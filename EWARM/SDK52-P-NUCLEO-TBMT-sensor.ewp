# IAR project SDK52-P-NUCLEO-TBMT-sensor.ewp, settings and files
configuration SDK52-P-NUCLEO-TBMT-sensor (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302x8 ST STM32F302x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32F302x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/F3xx/Inc; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDK52-P-NUCLEO-TBMT-sensor.hex
  ILINK.IlinkOutputFile: SDK52-P-NUCLEO-TBMT-sensor.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f302x8.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c stm32f30x_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32f3xx_it.c stm32f3xx_hal_msp.c main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c stm32f30x_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Middlewares/MotorControl
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c hall_speed_pos_fdbk.c mc_irq_handler.c mc_math.c mc_interface.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c bus_voltage_sensor.c circle_limitation.c digital_output.c hall_speed_pos_fdbk.c mc_irq_handler.c mc_math.c mc_interface.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/F3xx/Src/: r3_1_f30x_pwm_curr_fdbk.c r3_1_f30x_pwm_curr_fdbk.c
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/UILibrary/Src/: dac_ui.c dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c dac_ui.c dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
